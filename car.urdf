Commit message: refactor: 重新写了一个仿真环境，但是存在问题

File: car.urdf (robot description, URDF)
Before this commit: robot car, 5 links, 4 joints
Links:
- removed link world
Joints:
- removed joint base_joint
